# Keil uVision project BLE_SampleProject.uvprojx, settings and files
target Application (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLE_SampleProject
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,DEBUG
  c misc: --C99 --gnu
  c include: .\Inc;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\BSP\STM32F4xx-Nucleo;.\Drivers\BSP\X-NUCLEO-IDB04A1;.\BLE\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;.\Drivers\CMSIS\Include;.\RTE\_Application;.\RTE\Device\STM32F401RETx;.\Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group User Code
    ./Src/: bluenrg_interface.c clock.c cube_hal_f4.c stm32xx_it.c main.c sensor_service.c fput_debug.c
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c
  group BLE/HCI
    ./BLE/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group BLE/HCI/Controller
    ./BLE/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group BLE/Interface
    ./BLE/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group BLE/Utils
    ./BLE/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c list.c osal.c
  group Drivers/Nucleo
    ./Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
    ./Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_uart.h
  group Drivers/CMSIS
    ./Src/: system_stm32f4xx.c
  group Drivers/IDB04A1
    ./Drivers/BSP/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c
  group Drivers/STM32f4xx_HAL
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group MDK_ARM
    ./: startup_stm32f401xe.s
software components: Compiler:I/O:STDOUT 1.1.0
