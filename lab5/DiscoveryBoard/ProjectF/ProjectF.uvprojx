# Keil uVision project ProjectF.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjectF
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx, HSE_VALUE=8000000
  c include: .\INC;.\Accelerometer\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SRC
    ./SRC/: main.c stm32f4xx_it.c timer.c dac.c gpio.c accelerometer.c error_func.c uart.c flash.c
  group Accelerometer
    ./Accelerometer/src/: LIS3DSH.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Compiler:I/O:STDOUT 1.1.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DAC 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:I2S 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:SRAM 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:USART 1.4.2, Device:Startup 2.4.2
